# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Basic\delay;.\Basic\rtc;.\Basic\sys;.\Basic\usart;.\Hardware\LED;.\Hardware\KEY;.\Basic\flash;.\Hardware\BUZZER;.\Hardware\TOUCH_KEY;.\Hardware\TM1640;.\Hardware\ENCODER;.\Hardware\LM75A;.\Basic\i2c;.\Hardware\OLED0561;.\Hardware\RELAY;.\Hardware\STEP_MOTOR;.\Hardware\RS485;.\Hardware\CAN;.\Basic\adc;.\Hardware\JoyStick;.\Hardware\MY1690;.\Basic\spi;.\Hardware\CH376;.\Hardware\KEYPAD4x4;.\Basic\nvic;.\Hardware\SG90;.\Basic\pwm;.\Hardware\DHT11;.\Hardware\MPU6050;.\Basic\iwdg;.\Basic\wwdg;.\Basic\tim;.\Basic\crc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/rtc/: rtc.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/flash/: flash.c
    ./Basic/i2c/: i2c.c
    ./Basic/adc/: adc.c
    ./Basic/spi/: spi.c
    ./Basic/nvic/: NVIC.c
    ./Basic/pwm/: pwm.c
    ./Basic/iwdg/: iwdg.c
    ./Basic/wwdg/: wwdg.c
    ./Basic/tim/: tim.c
    ./Basic/crc/: crc.c
  group Hardware
    ./Hardware/LED/: LED.c
    ./Hardware/TOUCH_KEY/: touch_key.c
    ./Hardware/RELAY/: relay.c
    ./Hardware/OLED0561/: oled0561.c
    ./Hardware/DHT11/: dht11.c
    ./Hardware/KEY/: key.c
    ./Hardware/BUZZER/: buzzer.c
