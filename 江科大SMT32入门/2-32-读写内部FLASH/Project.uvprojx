# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Basic\Delay;.\Hardware\OLED-0.96-4P-I2C;.\Hardware\LED;.\Hardware\Key;.\Hardware\Buzzer;.\Hardware\LightSensor;.\Hardware\CountSensor;.\Hardware\Encode;.\Basic\Timer;.\Hardware\PWM;.\Hardware\Servo;.\Hardware\Motor;.\Hardware\InputCapture;.\Hardware\ADC;.\Basic\DMA;.\Hardware\USART_SerialPort;.\Basic\SoftwareI2C;.\Hardware\MPU6050;.\Basic\SoftwareSPI;.\Hardware\W25Q64;.\Basic\HardwareSPI;.\Basic\MyRTC;.\Basic\MyFlash;.\User\Store
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c stm32f10x_it.c
    ./User/Store/: Store.c
  group Basic
    ./Basic/SoftwareSPI/: SoftwareSPI.c
    ./Basic/SoftwareI2C/: SoftwareI2C.c
    ./Basic/Timer/: Timer.c
    ./Basic/Delay/: Delay.c
    ./Basic/DMA/: MyDMA.c
    ./Basic/HardwareSPI/: HardwareSPI.c
    ./Basic/MyRTC/: MyRTC.c
    ./Basic/MyFlash/: MyFlash.c
  group Hardware
    ./Hardware/OLED-0.96-4P-I2C/: OLED.c
    ./Hardware/LED/: LED.c
    ./Hardware/Key/: Key.c
    ./Hardware/Buzzer/: Buzzer.c
    ./Hardware/LightSensor/: LightSensor.c
    ./Hardware/CountSensor/: CountSensor.c
    ./Hardware/Encode/: Encode.c
    ./Hardware/PWM/: PWM.c
    ./Hardware/InputCapture/: InputCapture.c
    ./Hardware/ADC/: ADC.c
    ./Hardware/USART_SerialPort/: USART_SerialPort.c
    ./Hardware/MPU6050/: MPU6050.c
    ./Hardware/W25Q64/: W25Q64.c
